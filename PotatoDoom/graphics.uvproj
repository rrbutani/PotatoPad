# Keil uVision project graphics.uvproj, settings and files
target PotatoDoom (ARM-ADS)
  device: TM4C1231C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: graphics
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: graphics.sct
  group Source
    ./: startup.s graphic.c physic.c input.c FiFo.c audio.c PotatoDoom.c
  group Contribution
    ./contrib/: fpu.c PLL.c UART.c
  group Drivers
    ./drivers/: ADC.c pwm.c
    ./drivers/sd_SPI/: diskio.c ff.c
    ./drivers/ST7735/: ST7735.c LCD.s Print.s
