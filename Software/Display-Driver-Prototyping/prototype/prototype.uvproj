# Keil uVision project prototype.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab6
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: common.c main.c pins.c SSD1289.c UART.c startup.s graphics.c common.h graphics.h pins.h SSD1289.h tm4c123gh6pm.h UART.h PLL.c PLL.h
