# Keil uVision project iotesting.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: iotesting
  c flags: Optim=1
  group Source Group 1
    ./: tm4c123gh6pm.h main.c startup.s
