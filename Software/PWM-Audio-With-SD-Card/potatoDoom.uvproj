# Keil uVision project potatoDoom.uvproj, settings and files
target Potato Doom (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: potatoDoom
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: common.c common.h graphic.c graphic.h macros.h main.c PotatoDoom.c PotatoDoom.h types.h
  group Contributed
    ./Contrib/: fpu.c fpu.h hw_nvic.h hw_types.h PLL.c PLL.h startup.s tm4c123gh6pm.h UART.c UART.h
  group Drivers
    ./Drivers/pwm/: pwm.c pwm.h
    ./Drivers/sd_SPI/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
    ./Drivers/ST7735/: LCD.s Print.h Print.s ST7735.c ST7735.h
